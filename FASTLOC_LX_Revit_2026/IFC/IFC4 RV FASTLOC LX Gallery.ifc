Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: 980b6a56-245b-4f3e-89c0-be112c0fcf14, VersionGUID: 124a029f-7436-4141-a56b-957e7399880a, NumberOfSaves: 4], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [BuildingService]
File name: IFC4 RV FASTLOC LX Gallery.ifc
Time: 2026-02-12T13:50:48+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ENG) - 26.4.0.32

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level:Level 1
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1813
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcBuildingElementProxy: Model Text:100, Model Text:100:760744
In: Level 1
Type - Other - Category: Generic Models; Family Name: Model Text
Type - Identity Data - Type Name: 100
Type - Text - Bold: no; Italic: no; Text Font: Arial; Text Size: 100 mm
Pset_BuildingElementProxyCommon - Reference: Model Text:100; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: Model Text:100
Other - Family: Model Text; Family and Type: Model Text: 100; Type: 100; Type Id: 1886
Constraints - Work Plane: Level : Level 1
Dimensions - Depth: 150 mm
Graphics - Horizontal Align: Left; Text: FASTLOC LX
Identity Data - Subcategory: Generic Models
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Model Text:50 (5)
In: Level 1
Type - Other - Category: Generic Models; Family Name: Model Text
Type - Identity Data - Type Name: 50
Type - Text - Bold: no; Italic: no; Text Font: Arial; Text Size: 50 mm
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Model Text:50
Pset_EnvironmentalImpactIndicators - Reference: Model Text:50
Other - Family: Model Text; Family and Type: Model Text: 50; Type: 50; Type Id: 953130
Constraints - Work Plane: Level : Level 1
Dimensions - Depth: 150 mm
Graphics - Horizontal Align: Left
Identity Data - Subcategory: Generic Models
Phasing - Phase Created: New Construction
Name (Model Text:50:...) | Text
953129 | DN 12/Do 16
953202 | DN 15/Do 20
953210 | DN 20/Do 25
953218 | DN 25/Do 32
953226 | DN 32/Do 40

# IfcDistributionPort (190)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_723476_1
Port_723476_2
Port_723476_3
Port_723482_1
Port_723482_2
Port_723482_3
Port_723490_1
Port_723490_2
Port_723490_3
Port_723498_1
Port_723498_2
Port_723498_3
Port_723506_1
Port_723506_2
Port_723506_3
Port_723514_1
Port_723514_2
Port_723514_3
Port_723522_1
Port_723522_2
Port_723522_3
Port_723530_1
Port_723530_2
Port_723530_3
Port_723538_1
Port_723538_2
Port_723538_3
Port_723546_1
Port_723546_2
Port_723546_3
Port_723554_1
Port_723554_2
Port_723554_3
Port_723562_1
Port_723562_2
Port_723562_3
Port_723570_1
Port_723570_2
Port_723570_3
Port_723578_1
Port_723578_2
Port_723578_3
Port_723586_1
Port_723586_2
Port_723586_3
Port_723594_1
Port_723594_2
Port_723594_3
Port_723602_1
Port_723602_2
Port_723602_3
Port_723610_1
Port_723610_2
Port_723610_3
Port_723618_1
Port_723618_2
Port_723618_3
Port_723626_1
Port_723626_2
Port_723626_3
Port_723634_1
Port_723634_2
Port_723634_3
Port_723642_1
Port_723642_2
Port_723642_3
Port_723650_1
Port_723650_2
Port_723650_3
Port_723658_1
Port_723658_2
Port_723658_3
Port_723666_1
Port_723666_2
Port_723666_3
Port_723674_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 589
Port_723674_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 589
Port_723674_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 589
Port_723680_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 595
Port_723680_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 595
Port_723680_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 595
Port_723686_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 606
Port_723686_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 606
Port_723686_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 606
Port_723692_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 610
Port_723692_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 610
Port_723692_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 610
Port_723698_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 613
Port_723698_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 613
Port_723698_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 613
Port_723709_1
Port_723709_2
Port_723716_1
Port_723716_2
Port_723719_1
Port_723719_2
Port_723722_1
Port_723722_2
Port_723725_1
Port_723725_2
Port_723744_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 638
Port_723744_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 638
Port_723746_1
Port_723746_2
Port_723753_1
Port_723753_2
Port_723756_1
Port_723756_2
Port_723759_1
Port_723759_2
Port_723772_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 654
Port_723772_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 654
Port_723776_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 656
Port_723776_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 656
Port_723778_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 657
Port_723778_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 657
Port_723780_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 658
Port_723780_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 658
Port_723782_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 659
Port_723782_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 659
Port_723794_1
Port_723794_2
Port_723798_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 666
Port_723798_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 666
Port_723800_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 667
Port_723824_1
Port_723824_2
Port_723831_1
Port_723831_2
Port_723838_1
Port_723838_2
Port_723845_1
Port_723845_2
Port_723871_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 691
Port_723871_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 691
Port_723926_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 714
Port_723926_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 714
Port_723931_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 716
Port_723931_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 716
Port_723936_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 718
Port_724173_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 792
Port_724173_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 792
Port_724178_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 794
Port_724178_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 794
Port_724183_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 796
Port_724183_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 796
Port_724188_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 798
Port_724188_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 798
Port_724193_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 800
Port_724193_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 800
Port_755539_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 217
Port_755539_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 217
Port_937679_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 9
Port_937679_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 9
Port_937684_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 229
Port_937684_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 229
Port_937687_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 259
Port_937687_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 259
Port_937690_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 291
Port_937690_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 291
Port_937693_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 298
Port_937693_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 298
Port_937696_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 309
Port_937696_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 309
Port_937808_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 224
Port_937808_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 224
Port_937813_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 327
Port_937813_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 327
Port_937818_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 348
Port_937818_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 348
Port_937821_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 364
Port_937821_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 364
Port_937826_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 390
Port_937826_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 390
Port_937831_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 403
Port_937831_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 403
Port_937838_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 408
Port_937838_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 408
Port_937946_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 53
Port_937946_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 53
Port_937951_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 333
Port_937951_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 333
Port_937956_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 392
Port_937956_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 392
Port_937961_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 406
Port_937961_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 406
Port_937966_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 411
Port_937966_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 411
Port_938225_3 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 409
Port_938225_4 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 409

# IfcDistributionSystem: Domestic Cold Water (42)
PredefinedType: DOMESTICCOLDWATER
Pset_DistributionSystemCommon - Reference: Piping System:Domestic Cold Water
Name
Domestic Cold Water 589
Domestic Cold Water 595
Domestic Cold Water 606
Domestic Cold Water 610
Domestic Cold Water 613
Domestic Cold Water 638
Domestic Cold Water 654
Domestic Cold Water 656
Domestic Cold Water 657
Domestic Cold Water 658
Domestic Cold Water 659
Domestic Cold Water 666
Domestic Cold Water 667
Domestic Cold Water 691
Domestic Cold Water 714
Domestic Cold Water 716
Domestic Cold Water 718
Domestic Cold Water 792
Domestic Cold Water 794
Domestic Cold Water 796
Domestic Cold Water 798
Domestic Cold Water 800
Domestic Cold Water 217
Domestic Cold Water 9
Domestic Cold Water 229
Domestic Cold Water 259
Domestic Cold Water 291
Domestic Cold Water 298
Domestic Cold Water 309
Domestic Cold Water 224
Domestic Cold Water 327
Domestic Cold Water 348
Domestic Cold Water 364
Domestic Cold Water 390
Domestic Cold Water 403
Domestic Cold Water 408
Domestic Cold Water 53
Domestic Cold Water 333
Domestic Cold Water 392
Domestic Cold Water 406
Domestic Cold Water 411
Domestic Cold Water 409

# IfcPipeFitting: FASTLOC_ Backplate elbow long LX:FSL Backplate elbow PL (2)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_ Backplate elbow long LX; T1: FSL Backplate elbow long LX; T2: FSL Backplate elbow long LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.31-419114-419114; Type Name: FSL Backplate elbow PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_ Backplate elbow long LX:FSL Backplate elbow PL; sets with these values: 2
Other - IsCustom: no; Type: FSL Backplate elbow PL; Family: FASTLOC_ Backplate elbow long LX; Family and Type: FASTLOC_ Backplate elbow long LX: FSL Backplate elbow PL; Type Id: 790531
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - a: 8 mm; Area: 0.00465431 m2; DN2: 15 mm; ID2: 15 mm; Maximum Size: 15 mm; Minimum Size: 15 mm; Size: 15 mmø; Z1: 23 mm
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm; Overall Size: 15 mmø
Name (FASTLOC_ Backplate elbow long LX:FSL Backplate elbow PL:...) | DN1 (mm) | DoF1 (mm) | ID1 (mm) | L2 (mm) | r (mm) | r/2 (mm) | Volume (m3) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
723800 | 12 | 11.6 | 7.9 | 42 | 5.8 | 2.9 | 0.0000233643 | 16 | REHAU kolanko ścienne FASTLOC 16 - Rp 1/2 długie | 4064299604017 | 13602421001 | 126 | Domestic Cold Water 667
723936 | 15 | 15.5 | 11.5 | 40 | 7.75 | 3.875 | 0.0000250447 | 14 | REHAU kolanko ścienne FASTLOC 20 - Rp 1/2 długie | 4064299603997 | 13602441001 | 136 | Domestic Cold Water 718

# IfcPipeFitting: FASTLOC_ Backplate elbow short LX:FSL Backplate elbow PL (4)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_ Backplate elbow short LX; T1: FSL Backplate elbow short LX; T2: FSL Backplate elbow short LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.30-419114-419114; Type Name: FSL Backplate elbow PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_ Backplate elbow short LX:FSL Backplate elbow PL; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_ Backplate elbow short LX; Family and Type: FASTLOC_ Backplate elbow short LX: FSL Backplate elbow PL; Type: FSL Backplate elbow PL; Type Id: 795617
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_ Backplate elbow short LX:FSL Backplate elbow PL:...) | a (mm) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF1 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | r (mm) | r/2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
723798 | 8 | 12 | 15 | 11.6 | 7.9 | 15 | 27.3 | 5.8 | 2.9 | 15 mmø-12 mmø | 0.0000171898 | 22.5 | 12.3 | REHAU kolanko ścienne FASTLOC 16 - Rp 1/2 krótkie | 4064299604024 | 13602411001 | 93 | Domestic Cold Water 666
723871 | 10 | 15 | 15 | 15.5 | 11.5 | 15 | 25 | 7.75 | 3.875 | 15 mmø-15 mmø | 0.0000185696 | 22.7 | 10 | REHAU kolanko ścienne FASTLOC 20 - Rp 1/2 krótkie | 4064299604000 | 13602431001 | 104 | Domestic Cold Water 691
723926 | 10 | 15 | 20 | 15.5 | 11.5 | 20 | 26 | 7.75 | 3.875 | 20 mmø-15 mmø | 0.0000249991 | 26 | 12 | REHAU kolanko ścienne FASTLOC 20 - Rp 3/4 krótkie | 4064299603980 | 13602451001 | 124 | Domestic Cold Water 714
723931 | 12.2 | 20 | 20 | 19.2 | 14.7 | 25 | 28.1 | 9.6 | 4.8 | 20 mmø-20 mmø | 0.0000213835 | 26.9 | 11.8 | REHAU kolanko ścienne FASTLOC 25 - Rp 3/4 krótkie | 4064299603973 | 13602461001 | 153 | Domestic Cold Water 716

# IfcPipeFitting: FASTLOC_Adapter with union nut LX:FSL A union nut PL (7)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Adapter with union nut LX; T1: FSL Adapter with union nut LX; T2: FSL Adapter with union nut LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.31-419114-419114; Type Name: FSL A union nut PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Adapter with union nut LX:FSL A union nut PL; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Adapter with union nut LX; Family and Type: FASTLOC_Adapter with union nut LX: FSL A union nut PL; Type: FSL A union nut PL; Type Id: 800153
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Adapter with union nut LX:FSL A union nut PL:...) | V1 | V2 | Angle (deg) | DN1 (mm) | DN2 (mm) | DoF2 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | L Swievel Nut (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | SLW (mm) | SLW*2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
937808 | no | yes | 60 | 12 | 15 | 24.2 | 7.9 | 12.5 | 14 | 12 | 15 | 12 | 15 mmø-12 mmø | 15.5 | 31 | 0.0000133532 | 9 | 10 | REHAU złączka przejściowa FASTLOC 16 - G 1/2 | 4064299604109 | 13602211001 | 51 | Domestic Cold Water 224
937813 | no | yes | 60 | 15 | 15 | 20 | 11.5 | 11.5 | 10 | 12.1 | 15 | 15 | 15 mmø-15 mmø | 15.5 | 31 | 0.0000140033 | 9 | 13 | REHAU złączka przejściowa FASTLOC 20 - G 1/2 | 4064299604093 | 13602221001 | 59 | Domestic Cold Water 327
937818 | no | yes | 60 | 15 | 20 | 24 | 11.5 | 16.3 | 14.1 | 12.1 | 20 | 15 | 20 mmø-15 mmø | 15.5 | 31 | 0.0000141018 | 9 | 11.7 | REHAU złączka przejściowa FASTLOC 20 - G 3/4 | 4064299605670 | 13602271001 | 72 | Domestic Cold Water 348
937821 | no | yes | 60 | 20 | 20 | 30.6 | 14.7 | 21 | 15.5 | 12.2 | 20 | 20 | 20 mmø-20 mmø | 19.25 | 38.5 | 0.0000190835 | 10.3 | 13.5 | REHAU złączka przejściowa FASTLOC 25 - G 3/4 | 4064299604086 | 13602231001 | 91 | Domestic Cold Water 364
937826 | no | yes | 60 | 25 | 25 | 38 | 19.7 | 28.3 | 16.5 | 13.5 | 25 | 25 | 25 mmø-25 mmø | 23.25 | 46.5 | 0.0000285978 | 11.5 | 13.5 | REHAU złączka przejściowa FASTLOC 32 - G 1 | 4064299692274 | 13602241001 | 171 | Domestic Cold Water 390
937831 | yes | no | 45 | 32 | 32 | 44.5 | 23.9 | 30 | 16.5 | 14 | 32 | 32 | 32 mmø-32 mmø | 26.5 | 53 | 0.0000354681 | 11.5 | 16 | REHAU złączka przejściowa FASTLOC 40 - G 1 1/2 | 4064299692281 | 13602251001 | 308 | Domestic Cold Water 403
937838 | no | yes | 60 | 12 | 10 | 16.3 | 8.3 | 8.3 | 9 | 12 | 12 | 10 | 12 mmø-10 mmø | 15.5 | 31 | 0.000015659 | 9 | 9 | REHAU złączka przejściowa FASTLOC 16 - G 3/8 | 4064299605663 | 13602191001 | 40 | Domestic Cold Water 408

# IfcPipeFitting: FASTLOC_Adapter_LX, with external thread:FSL A C external PL (6)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Adapter_LX, with external thread; T1: FSL Adapter coupling external thread LX; T2: FSL Adapter coupling external thread LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.31-419114-419114; Type Name: FSL A C external PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Adapter_LX, with external thread:FSL A C external PL; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Adapter_LX, with external thread; Family and Type: FASTLOC_Adapter_LX, with external thread: FSL A C external PL; Type: FSL A C external PL; Type Id: 804324
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Adapter_LX, with external thread:FSL A C external PL:...) | A (deg) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | SWL (mm) | SWL/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
723744 | 60 | 12 | 15 | 7.9 | 15 | 15 mmø-12 mmø | 27 | 13.5 | 0.00000814674 | 8.9 | 7.8 | REHAU złączka przejściowa FASTLOC 16 - R 1/2 | 4064299604178 | 13602011001 | 45 | Domestic Cold Water 638
723772 | 60 | 15 | 15 | 11.5 | 15 | 15 mmø-15 mmø | 27 | 13.5 | 0.00000934968 | 8.7 | 8.4 | REHAU złączka przejściowa FASTLOC 20 - R 1/2 | 4064299604161 | 13602021001 | 52 | Domestic Cold Water 654
723776 | 45 | 15 | 20 | 11.5 | 19 | 20 mmø-15 mmø | 23 | 11.5 | 0.0000110366 | 9.3 | 12.5 | REHAU złączka przejściowa FASTLOC 20 - R 3/4 | 4064299604154 | 13602031001 | 75 | Domestic Cold Water 656
723778 | 45 | 20 | 20 | 14.7 | 19 | 20 mmø-20 mmø | 23 | 11.5 | 0.0000130542 | 9.4 | 12.9 | REHAU złączka przejściowa FASTLOC 25 - R 3/4 | 4064299604147 | 13602041001 | 94 | Domestic Cold Water 657
723780 | 45 | 25 | 25 | 19.7 | 24 | 25 mmø-25 mmø | 36 | 18 | 0.0000243124 | 14.6 | 8.7 | REHAU złączka przejściowa FASTLOC 32 - R 1 | 4064299692236 | 13602051001 | 182 | Domestic Cold Water 658
723782 | 45 | 32 | 32 | 23.9 | 30 | 32 mmø-32 mmø | 36 | 18 | 0.0000403809 | 16.4 | 13 | REHAU złączka przejściowa FASTLOC 40 - R 1 1/4 | 4064299692243 | 13602061001 | 299 | Domestic Cold Water 659

# IfcPipeFitting: FASTLOC_Adapter_LX, with internal thread:FSL A internal PL (6)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Adapter_LX, with internal thread; T1: FSL Adapter with internal thread LX; T2: FSL Adapter with internal thread LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.30-419114-419114; Type Name: FSL A internal PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Adapter_LX, with internal thread:FSL A internal PL; sets with these values: 2
Other - IsCustom: no; Type: FSL A internal PL; Family: FASTLOC_Adapter_LX, with internal thread; Family and Type: FASTLOC_Adapter_LX, with internal thread: FSL A internal PL; Type Id: 808094
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Adapter_LX, with internal thread:FSL A internal PL:...) | V1 | V2 | Angle (deg) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF2 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | Size = Overall Size | SLW (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
937679 | no | yes | 60 | 12 | 15 | 25.5 | 7.9 | 18.6 | 16.2 | 15 mmø-12 mmø | 13.5 | 0.00000823241 | 12.4 | 7.3 | REHAU złączka przejściowa FASTLOC 16 - Rp 1/2 | 4064299604130 | 13602111001 | 63 | Domestic Cold Water 9
937684 | yes | no | 45 | 15 | 20 | 32 | 11.5 | 24.1 | 17.7 | 20 mmø-15 mmø | 17 | 0.0000130791 | 13.3 | 8.1 | REHAU złączka przejściowa FASTLOC 20 - Rp 3/4 | 4064299605656 | 13602161001 | 101 | Domestic Cold Water 229
937687 | yes | no | 45 | 20 | 20 | 32 | 14.7 | 24.1 | 17.7 | 20 mmø-20 mmø | 17 | 0.0000147372 | 12.9 | 8.7 | REHAU złączka przejściowa FASTLOC 25 - Rp 3/4 | 4064299604116 | 13602131001 | 118 | Domestic Cold Water 259
937690 | yes | no | 45 | 25 | 25 | 38.5 | 19.7 | 30.4 | 20.6 | 25 mmø-25 mmø | 20.5 | 0.0000240543 | 14.5 | 8.8 | REHAU złączka przejściowa FASTLOC 32 - Rp 1 | 4064299692250 | 13602141001 | 192 | Domestic Cold Water 291
937693 | yes | no | 45 | 32 | 32 | 50 | 23.9 | 39 | 22.8 | 32 mmø-32 mmø | 25 | 0.0000446492 | 20 | 10.8 | REHAU złączka przejściowa FASTLOC 40 - Rp 1 1/4 | 4064299692267 | 13602151001 | 333 | Domestic Cold Water 298
937696 | no | yes | 60 | 15 | 15 | 25.5 | 11.5 | 18.7 | 16.2 | 15 mmø-15 mmø | 13.5 | 0.00000863182 | 11.7 | 7.3 | REHAU złączka przejściowa FASTLOC 20 - Rp 1/2 | 4064299604123 | 13602121001 | 68 | Domestic Cold Water 309

# IfcPipeFitting: FASTLOC_Blanking plug LX:FSL Bp LX PL (2)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Blanking plug LX; T1: FSL Blanking plug LX; T2: FSL Blanking plug LX DN1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.31-419114-419114; Type Name: FSL Bp LX PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Blanking plug LX:FSL Bp LX PL; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Blanking plug LX; Family and Type: FASTLOC_Blanking plug LX: FSL Bp LX PL; Type: FSL Bp LX PL; Type Id: 811768
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2; Z1: 6.7 mm
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Blanking plug LX:FSL Bp LX PL:...) | DN1 (mm) | ID1 (mm) | Volume (m3) | Description long | GTIN | PID | Weight
723802 | 12 | 7.9 | 0.0000014275 | REHAU zaślepka FASTLOC 16 | 4064299604383 | 13601461001 | 14
723944 | 15 | 11.5 | 0.00000223472 | REHAU zaślepka FASTLOC 20 | 4064299604376 | 13601471001 | 23

# IfcPipeFitting: FASTLOC_Corner LX:FSL C LX PL (5)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Corner LX; T1: FSL Corner LX; T2: FSL Corner DN1+2 LX
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.31-419114-419114; Type Name: FSL C LX PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Corner LX:FSL C LX PL; sets with these values: 2
Other - IsCustom: no; Type: FSL C LX PL; Family: FASTLOC_Corner LX; Family and Type: FASTLOC_Corner LX: FSL C LX PL; Type Id: 815872
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.0041524 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Corner LX:FSL C LX PL:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) = ID2 (mm) | r (mm) | r/2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Weight
723794 | 12 | 7.9 | 8 | 4 | 12 mmø-12 mmø | 0.00000473902 | 22.1 | REHAU kolanko FASTLOC 16 - 16, 90° | 4064299604413 | 13601411001 | 40
723824 | 15 | 11.5 | 10 | 5 | 15 mmø-15 mmø | 0.00000783137 | 24.6 | REHAU kolanko FASTLOC 20 - 20, 90° | 4064299604406 | 13601421001 | 64
723831 | 20 | 14.7 | 12.5 | 6.25 | 20 mmø-20 mmø | 0.00001402 | 29 | REHAU kolanko FASTLOC 25 - 25, 90° | 4064299604390 | 13601431001 | 118
723838 | 25 | 19.7 | 16 | 8 | 25 mmø-25 mmø | 0.0000279902 | 35 | REHAU kolanko FASTLOC 32 - 32, 90° | 4064299692298 | 13601441001 | 219
723845 | 32 | 23.9 | 20 | 10 | 32 mmø-32 mmø | 0.0000541103 | 44.7 | REHAU kolanko FASTLOC 40 - 40, 90° | 4064299692304 | 13601451001 | 416

# IfcPipeFitting: FASTLOC_Coupling equal LX:FSL C LX PL (5)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Coupling equal LX; T1: FSL Coupling LX; T2: FSL Coupling LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.31-419114-419114; Type Name: FSL C LX PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Coupling equal LX:FSL C LX PL; sets with these values: 2
Other - IsCustom: no; V1: yes; V2: no; Family: FASTLOC_Coupling equal LX; Family and Type: FASTLOC_Coupling equal LX: FSL C LX PL; Type: FSL C LX PL; Type Id: 819624
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Coupling equal LX:FSL C LX PL:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) = ID2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Weight
723709 | 12 | 7.9 | 12 mmø-12 mmø | 0.00000280869 | 7.2 | REHAU złączka FASTLOC 16 - 16 | 4064299604468 | 13601311001 | 29
723716 | 15 | 11.5 | 15 mmø-15 mmø | 0.00000445267 | 7.4 | REHAU złączka FASTLOC 20 - 20 | 4064299604451 | 13601321001 | 45
723719 | 20 | 14.7 | 20 mmø-20 mmø | 0.00000812421 | 8 | REHAU złączka FASTLOC 25 - 25 | 4064299604444 | 13601331001 | 84
723722 | 25 | 19.7 | 25 mmø-25 mmø | 0.0000165656 | 10 | REHAU złączka FASTLOC 32 - 32 | 4064299692199 | 13601341001 | 159
723725 | 32 | 23.9 | 32 mmø-32 mmø | 0.0000306965 | 12.7 | REHAU złączka FASTLOC 40 - 40 | 4064299692205 | 13601351001 | 295

# IfcPipeFitting: FASTLOC_Coupling reduced LX:FSL C LX PL (4)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Coupling reduced LX; T1: FSL Coupling LX; T2: FSL Coupling LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.31-419114-419114; Type Name: FSL C LX PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Coupling reduced LX:FSL C LX PL; sets with these values: 2
Other - IsCustom: no; V1: no; V2: yes; Type: FSL C LX PL; Family: FASTLOC_Coupling reduced LX; Family and Type: FASTLOC_Coupling reduced LX: FSL C LX PL; Type Id: 823381
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Coupling reduced LX:FSL C LX PL:...) | DN1 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight
723746 | 15 | 12 | 11.5 | 7.9 | 15 mmø-12 mmø | 0.00000382612 | 8.7 | 6.3 | REHAU złączka FASTLOC 20 - 16 | 4064299604437 | 13601361001 | 37
723753 | 20 | 15 | 14.7 | 11.5 | 20 mmø-15 mmø | 0.00000660281 | 9.8 | 5.7 | REHAU złączka FASTLOC 25 - 20 | 4064299604420 | 13601371001 | 64
723756 | 25 | 20 | 19.7 | 14.7 | 25 mmø-20 mmø | 0.0000132006 | 12.4 | 5.8 | REHAU złączka FASTLOC 32 - 25 | 4064299692212 | 13601381001 | 120
723759 | 32 | 25 | 23.9 | 19.7 | 32 mmø-25 mmø | 0.0000245636 | 11.6 | 10.9 | REHAU złączka FASTLOC 40 - 32 | 4064299692229 | 13601391001 | 224

# IfcPipeFitting: FASTLOC_Elbow with female thread LX:FSL A internal PL (5)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Elbow with female thread LX; T1: FSL Elbow with female thread LX; T2: FSL Elbow with female thread LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.31-419114-419114; Type Name: FSL A internal PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Elbow with female thread LX:FSL A internal PL; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Elbow with female thread LX; Family and Type: FASTLOC_Elbow with female thread LX: FSL A internal PL; Type: FSL A internal PL; Type Id: 827528
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2; L SLW: 10 mm
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Elbow with female thread LX:FSL A internal PL:...) | V1 | V2 | a (mm) | Angle (deg) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF1 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | r (mm) | r/2 (mm) | Size = Overall Size | SLW (mm) | SLW/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
724173 | no | yes | 8 | 60 | 12 | 15 | 11.6 | 7.9 | 15 | 23 | 5.8 | 2.9 | 15 mmø-12 mmø | 27 | 13.5 | 0.0000160215 | 22.3 | 5 | REHAU kolanko przejściowe FASTLOC 16 - Rp 1/2 | 4064299604079 | 13602311001 | 68 | Domestic Cold Water 792
724178 | no | yes | 10 | 60 | 15 | 15 | 15.5 | 11.5 | 15 | 25 | 7.75 | 3.875 | 15 mmø-15 mmø | 27 | 13.5 | 0.0000178946 | 22.7 | 5 | REHAU kolanko przejściowe FASTLOC 20 - Rp 1/2 | 4064299604062 | 13602321001 | 81 | Domestic Cold Water 794
724183 | no | yes | 11.7 | 60 | 15 | 20 | 15.5 | 11.5 | 20 | 28 | 7.75 | 3.875 | 20 mmø-15 mmø | 34 | 17 | 0.000027102 | 26 | 5.3 | REHAU kolanko przejściowe FASTLOC 20 - Rp 3/4 | 4064299604055 | 13602331001 | 115 | Domestic Cold Water 796
724188 | no | yes | 12.2 | 60 | 20 | 20 | 19.2 | 14.7 | 25 | 28.5 | 9.6 | 4.8 | 20 mmø-20 mmø | 34 | 17 | 0.0000265064 | 27 | 5.3 | REHAU kolanko przejściowe FASTLOC 25 - Rp 3/4 | 4064299604048 | 13602341001 | 139 | Domestic Cold Water 798
724193 | yes | no | 15.4 | 45 | 25 | 25 | 25 | 19.7 | 25 | 34.5 | 12.5 | 6.25 | 25 mmø-25 mmø | 41 | 20.5 | 0.0000505262 | 32 | 6.1 | REHAU kolanko przejściowe FASTLOC 32 - Rp 1 | 4064299604031 | 13602351001 | 234 | Domestic Cold Water 800

# IfcPipeFitting: FASTLOC_Elbow with male thread G LX:FSL A internal PL, FASTLOC_Elbow with male thread G LX:FSL A internal PL:938225
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Elbow with male thread G LX; T1: FSL Elbow with male thread G LX; T2: FSL Elbow with male thread G LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.31-419114-419114; Type Name: FSL A internal PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Materials and Finishes - REH_MATERIAL: lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat); Group: Domestic Cold Water 409
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Elbow with male thread G LX:FSL A internal PL; sets with these values: 2
Other - IsCustom: no; V1: no; V2: yes; Type: FSL A internal PL; Family: FASTLOC_Elbow with male thread G LX; Family and Type: FASTLOC_Elbow with male thread G LX: FSL A internal PL; r: 5.8 mm; r2: 3.75 mm; Type Id: 831758
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Angle: 60 deg; a: 9 mm; Area: 0.00465431 m2; DN1: 12 mm; DN2: 12 mm; DoF1: 11.6 mm; DoF2: 16.3 mm; ID1: 7.9 mm; ID2: 10.2 mm; L2: 25.5 mm; Maximum Size: 12 mm; Minimum Size: 12 mm; Size: 12 mmø-12 mmø; SLW: 10.5 mm; Volume: 0.000006449 m3; Z1: 17.8 mm; Z2: 6.5 mm
Graphics - Use Annotation Scale: no
Identity Data - Description long: REHAU kolanko przejściowe FASTLOC 16 - G 3/8 (gwint zewnętrzny); ETIM Class code: EC003025; GTIN: 4064299605694; PID: 13602381001; Weight: 42
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water; System Name: Domestic Cold Water 409
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm; Overall Size: 12 mmø-12 mmø

# IfcPipeFitting: FASTLOC_Elbow with male thread LX:FSL A internal PL (5)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Elbow with male thread LX; T1: FSL Elbow with male thread LX; T2: FSL Elbow with male thread LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.31-419114-419114; Type Name: FSL A internal PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Materials and Finishes - REH_MATERIAL: lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Elbow with male thread LX:FSL A internal PL; sets with these values: 2
Other - IsCustom: no; Type: FSL A internal PL; Family: FASTLOC_Elbow with male thread LX; Family and Type: FASTLOC_Elbow with male thread LX: FSL A internal PL; Type Id: 835977
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Elbow with male thread LX:FSL A internal PL:...) | V1 | V2 | r (mm) | r2 (mm) | Angle (deg) | a (mm) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF1 (mm) | DoF2 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | Size = Overall Size | SLW (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
937946 | no | yes | 5.8 | 3.75 | 60 | 9.5 | 12 | 15 | 11.6 | 20.6 | 7.9 | 14 | 29.2 | 15 mmø-12 mmø | 10.5 | 0.00000733756 | 19.8 | 6.5 | REHAU kolanko przejściowe FASTLOC 16 - R 1/2 | 4067936327775 | 13620761001 | 59 | Domestic Cold Water 53
937951 | no | yes | 7.75 | 6 | 60 | 13.8 | 15 | 15 | 15.5 | 20.6 | 11.5 | 14 | 33.5 | 15 mmø-15 mmø | 10.5 | 0.00000924107 | 20.2 | 6.5 | REHAU kolanko przejściowe FASTLOC 20 - R 1/2 | 4067936327782 | 13620771001 | 73 | Domestic Cold Water 333
937956 | no | yes | 7.75 | 6 | 60 | 13.8 | 15 | 15 | 15.5 | 20.6 | 11.5 | 14 | 33.5 | 15 mmø-15 mmø | 10.5 | 0.00000924107 | 20.2 | 6.5 | REHAU kolanko przejściowe FASTLOC 20 - R 1/2 | 4067936327782 | 13620771001 | 73 | Domestic Cold Water 392
937961 | yes | no | 9.6 | 6.95 | 45 | 16.5 | 20 | 20 | 19.2 | 26 | 14.7 | 19 | 37.5 | 20 mmø-20 mmø | 13.5 | 0.0000157038 | 24.2 | 6.5 | REHAU kolanko przejściowe FASTLOC 25 - R 3/4 | 4067936327799 | 13620781001 | 115 | Domestic Cold Water 406
937966 | yes | no | 12.5 | 9.85 | 45 | 21 | 25 | 25 | 25 | 32.6 | 19.7 | 24 | 44.8 | 25 mmø-25 mmø | 17 | 0.0000294403 | 29.7 | 7 | REHAU kolanko przejściowe FASTLOC 32 - R 1 | 4067936344109 | 13620791001 | 211 | Domestic Cold Water 411

# IfcPipeFitting: FASTLOC_Elbow with union connector LX:FSL E with union connector LX PL, FASTLOC_Elbow with union connector LX:FSL E with union connector LX PL:755539
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Elbow with union connector LX; T1: FSL Elbow with union connector LX; T2: FSL Elbow with union connector LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.30-419114-419114; Type Name: FSL E with union connector LX PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat); Group: Domestic Cold Water 217
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Elbow with union connector LX:FSL E with union connector LX PL; sets with these values: 2
Other - IsCustom: no; V1: no; V2: yes; Family: FASTLOC_Elbow with union connector LX; Family and Type: FASTLOC_Elbow with union connector LX: FSL E with union connector LX PL; Type: FSL E with union connector LX PL; Type Id: 844341
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Angle: 60 deg; a: 20 mm; Area: 0.00465431 m2; DN1: 12 mm; DN2: 12 mm; DoF1: 11.6 mm; DoF2: 25.5 mm; ID1: 7.9 mm; ID2: 15 mm; L2: 28 mm; L SLW: 10 mm; Maximum Size: 12 mm; Minimum Size: 12 mm; r: 5.8 mm; r/2: 2.9 mm; Size: 12 mmø-12 mmø; SLW: 27 mm; SLW/2: 13.5 mm; Volume: 0.00000825681 m3; Z1: 21 mm; Z2: 8 mm
Graphics - Use Annotation Scale: no
Identity Data - Description long: REHAU kolanko przejściowe FASTLOC 16 - G 3/8; ETIM Class code: EC003025; GTIN: 4064299606301; PID: 13602391001; Weight: 50
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water; System Name: Domestic Cold Water 217
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm; Overall Size: 12 mmø-12 mmø

# IfcPipeFitting: FASTLOC_Sleeve outside:FSL S O DN1 (152)
In: Level 1
Type - Material: PX
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Sleeve outside
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.04.22-419114-419114; Type Name: FSL S O DN1; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Sleeve outside:FSL S O DN1; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Sleeve outside; Family and Type: FASTLOC_Sleeve outside: FSL S O DN1; Type: FSL S O DN1; Type Id: 975272
Constraints - Elevation from Level: 0 mm; Level: Level 1; Moves With Nearby Elements: no
Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Identity Data - ETIM Class code: EC003025; GTIN: SH FASTLOC; PID: SH FASTLOC; PID SEAP: N/A
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Sleeve outside:FSL S O DN1:...) | Area (m2) | DN1 (mm) | ID1 (mm) | Volume (m3) | Description long | Weight
975394 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
975401 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
981775 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
981784 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
981791 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
981799 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
987654 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
987660 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
987666 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
987674 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
987678 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
987689 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
987700 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
993160 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
993168 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
993174 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
993182 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
993192 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
993202 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
1011830 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
