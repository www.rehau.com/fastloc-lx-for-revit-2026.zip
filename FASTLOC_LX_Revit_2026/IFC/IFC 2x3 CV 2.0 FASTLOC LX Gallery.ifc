Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowFitting: FASTLOC_Sleeve outside:FSL S O DN1 (152)
Name (FASTLOC_Sleeve outside:FSL S O DN1:...) | Area (m2) | DN1 (mm) | ID1 (mm) | Volume (m3) | Description long | Weight
1044131 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1044139 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1048366 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1052566 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1052568 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1052576 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1052578 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1052588 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1052590 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1052596 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1052598 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1052608 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
1052610 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
1057362 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1057364 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1057366 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1057376 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057378 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057380 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057392 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057394 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057396 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057408 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057410 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057412 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057424 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
1057426 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
1057428 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
1057441 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057443 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057445 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057460 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057462 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057464 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057477 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057479 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
1057481 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
1057496 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057498 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
1057500 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
1057515 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057517 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
1057519 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
1057529 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1057531 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057533 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057545 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1057547 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057549 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057562 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057564 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057566 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057578 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1057580 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057582 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057592 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057594 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057596 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1057608 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057610 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057612 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1057625 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057627 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057629 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057645 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057647 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057649 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057665 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057667 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057669 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057684 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057686 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057688 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057703 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057705 | 0.00729828 | 32 | 40.4 | 0.0000223458 | REHAU FASTLOC Schiebehülse außen 40 | 40.2
1057707 | 0.00491465 | 25 | 32.4 | 0.0000124004 | REHAU FASTLOC Schiebehülse außen 32 | 26.5
1057717 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1057719 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057721 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1057733 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1057735 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057737 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1057750 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8
1057752 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057754 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057767 | 0.0018795 | 15 | 20.3 | 0.00000362058 | REHAU FASTLOC Schiebehülse außen 20 | 7.2
1057769 | 0.00314365 | 20 | 25.3 | 0.00000758784 | REHAU FASTLOC Schiebehülse außen 25 | 15.5
1057771 | 0.00139513 | 12 | 16.3 | 0.00000253912 | REHAU FASTLOC Schiebehülse außen 16 | 4.8

# IfcFlowFitting: FASTLOC_T-piece internal thread LX:FSL T thread LX PL (5)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_T-piece internal thread LX; T1: FSL T-piece internal thread LX; T2: FSL T-piece internal thread DN1+3 LX
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.10.30-419114-419114; Type Name: FSL T thread LX PL; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_T-piece internal thread LX:FSL T thread LX PL; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_T-piece internal thread LX; Family and Type: FASTLOC_T-piece internal thread LX: FSL T thread LX PL; Type: FSL T thread LX PL; Type Id: 850922
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Classification: Domestic Cold Water; System Type: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_T-piece internal thread LX:FSL T thread LX PL:...) | DN1 (mm) = DN3 (mm) | DN2 (mm) = ID2 (mm) | ID1 (mm) = ID3 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z3 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
723674 | 12 | 15 | 7.9 | 15 | 12 | 15 mmø-12 mmø-12 mmø | 0.0000127024 | 22 | 9.4 | REHAU trójnik FASTLOC 16 - Rp 1/2 - 16 | 4064299604208 | 13601911001 | 83 | Domestic Cold Water 589
723680 | 15 | 15 | 11.5 | 15 | 15 | 15 mmø-15 mmø-15 mmø | 0.0000151523 | 22.5 | 10.4 | REHAU trójnik FASTLOC 20 - Rp 1/2 - 20 | 4064299604192 | 13601921001 | 103 | Domestic Cold Water 595
723686 | 20 | 15 | 14.7 | 20 | 15 | 20 mmø-20 mmø-15 mmø | 0.0000207221 | 26.7 | 12.2 | REHAU trójnik FASTLOC 25 - Rp 3/4 - 25 | 4064299604185 | 13601931001 | 178 | Domestic Cold Water 606
723692 | 25 | 25 | 19.7 | 25 | 25 | 25 mmø-25 mmø-25 mmø | 0.0000381882 | 33 | 12.5 | REHAU trójnik FASTLOC 32 - Rp 1 - 32 | 4064299692175 | 13601941001 | 314 | Domestic Cold Water 610
723698 | 32 | 32 | 23.9 | 32 | 32 | 32 mmø-32 mmø-32 mmø | 0.0000645993 | 41.3 | 19.8 | REHAU trójnik FASTLOC 40 - Rp 1 1/4 - 40 | 4064299692182 | 13601951001 | 562 | Domestic Cold Water 613

# IfcFlowFitting: FASTLOC_T-piece_LX:FSL T-Piece LX PL (25)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_T-piece_LX; T1: FSL T-piece LX; T2: FSL T-piece LX DN1+3
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description pl; Region Check: Check PL; Region PID: PID PL
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.27.43.00; Manufacturer: REHAU; Model: FASTLOC LX; REHAU Info: 2024.11.04-419114-419114; Type Comments: bim@rehau.com; Type Name: FSL T-Piece LX PL
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_T-piece_LX:FSL T-Piece LX PL; sets with these values: 2
Other - Family: FASTLOC_T-piece_LX; Family and Type: FASTLOC_T-piece_LX: FSL T-Piece LX PL; IsCustom: no; Type: FSL T-Piece LX PL; Type Id: 855620
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.000461378 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_T-piece_LX:FSL T-Piece LX PL:...) | V1 | V2 | DN1 (mm) = Maximum Size (mm) | DN2 (mm) | DN3 (mm) | ID 3 (mm) | Minimum Size (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | Description long | GTIN | PID | Weight
723476 | yes | no | 12 | 12 | 12 | 7.9 | 12 | 12 mmø-12 mmø-12 mmø | 0.00000598256 | 15 | 22.1 | 15 | REHAU trójnik FASTLOC 16 - 16 - 16 | 4064299604338 | 13601611001 | 52
723482 | yes | no | 15 | 15 | 15 | 11.5 | 15 | 15 mmø-15 mmø-15 mmø | 0.00000991242 | 17.2 | 26.4 | 17.2 | REHAU trójnik FASTLOC 20 - 20 - 20 | 4064299604321 | 13601621001 | 84
723490 | yes | no | 20 | 20 | 20 | 14.7 | 20 | 20 mmø-20 mmø-20 mmø | 0.0000175543 | 19.9 | 29.5 | 19.9 | REHAU trójnik FASTLOC 25 - 25 - 25 | 4064299604314 | 13601631001 | 153
723498 | yes | no | 25 | 25 | 25 | 19.7 | 25 | 25 mmø-25 mmø-25 mmø | 0.0000352841 | 24.8 | 36.1 | 24.8 | REHAU trójnik FASTLOC 32 - 32 - 32 | 4064299691956 | 13601641001 | 287
723506 | yes | no | 32 | 32 | 32 | 24 | 32 | 32 mmø-32 mmø-32 mmø | 0.0000663841 | 31.4 | 44.7 | 31.4 | REHAU trójnik FASTLOC 40 - 40 - 40 | 4064299691963 | 13601651001 | 538
723514 | yes | no | 25 | 15 | 25 | 19.7 | 15 | 25 mmø-25 mmø-15 mmø | 0.0000253879 | 20.2 | 34 | 20.2 | REHAU trójnik FASTLOC 32 - 20 - 32 | 4064299691987 | 13601711001 | 211
723522 | yes | no | 25 | 20 | 25 | 19.7 | 20 | 25 mmø-25 mmø-20 mmø | 0.0000282607 | 22 | 34.4 | 22 | REHAU trójnik FASTLOC 32 - 25 - 32 | 4064299691994 | 13601721001 | 237
723530 | yes | no | 32 | 15 | 32 | 23.9 | 15 | 32 mmø-32 mmø-15 mmø | 0.0000425926 | 24 | 40.5 | 24 | REHAU trójnik FASTLOC 40 - 20 - 40 | 4064299692106 | 13601731001 | 362
723538 | yes | no | 32 | 20 | 32 | 23.9 | 20 | 32 mmø-32 mmø-20 mmø | 0.0000466619 | 25.8 | 41 | 25.8 | REHAU trójnik FASTLOC 40 - 25 - 40 | 4064299692113 | 13601741001 | 395
723546 | yes | no | 32 | 25 | 32 | 23.9 | 25 | 32 mmø-32 mmø-25 mmø | 0.0000548368 | 28.6 | 42.8 | 28.6 | REHAU trójnik FASTLOC 40 - 32 - 40 | 4064299692120 | 13601751001 | 449
723554 | yes | no | 15 | 12 | 15 | 11.5 | 12 | 15 mmø-15 mmø-12 mmø | 0.00000828706 | 15.3 | 26.3 | 15.3 | REHAU trójnik FASTLOC 20 - 16 - 20 | 4064299604307 | 13601661001 | 71
723562 | yes | no | 20 | 12 | 20 | 14.7 | 12 | 20 mmø-20 mmø-12 mmø | 0.0000127363 | 16.2 | 29 | 16.2 | REHAU trójnik FASTLOC 25 - 16 - 25 | 4064299604291 | 13601671001 | 115
723570 | yes | no | 20 | 15 | 20 | 14.7 | 15 | 20 mmø-20 mmø-15 mmø | 0.0000145715 | 18.1 | 29.2 | 18.1 | REHAU trójnik FASTLOC 25 - 20 - 25 | 4064299604284 | 13601681001 | 128
723578 | yes | no | 25 | 12 | 25 | 19.7 | 12 | 25 mmø-25 mmø-12 mmø | 0.0000226341 | 18.3 | 33.9 | 18.3 | REHAU trójnik FASTLOC 32 - 16 - 32 | 4064299691970 | 13601691001 | 196
723586 | no | yes | 15 | 15 | 12 | 7.9 | 12 | 15 mmø-12 mmø-15 mmø | 0.00000905048 | 17.4 | 26.4 | 17 | REHAU trójnik FASTLOC 20 - 20 - 16 | 4064299604277 | 13601761001 | 78
723594 | no | yes | 20 | 20 | 12 | 7.9 | 12 | 20 mmø-12 mmø-20 mmø | 0.000015009 | 20.1 | 29.5 | 18.8 | REHAU trójnik FASTLOC 25 - 25 - 16 | 4064299604260 | 13601771001 | 127
723602 | no | yes | 20 | 15 | 15 | 11.5 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000126368 | 18.3 | 29.2 | 17.4 | REHAU trójnik FASTLOC 25 - 20 - 20 | 4064299604215 | 13601831001 | 111
723610 | no | yes | 25 | 15 | 20 | 14.7 | 15 | 25 mmø-20 mmø-15 mmø | 0.0000202673 | 20.3 | 34 | 18.3 | REHAU trójnik FASTLOC 32 - 20 - 25 | 4064299692137 | 13601841001 | 176
723618 | no | yes | 25 | 20 | 15 | 11.5 | 15 | 25 mmø-15 mmø-20 mmø | 0.0000219032 | 22.1 | 34.4 | 19.2 | REHAU trójnik FASTLOC 32 - 25 - 20 | 4067936119738 | 13601851001 | 184
723626 | no | yes | 25 | 20 | 20 | 14.7 | 20 | 25 mmø-20 mmø-20 mmø | 0.0000240836 | 22.1 | 34.4 | 20.1 | REHAU trójnik FASTLOC 32 - 25 - 25 | 4064299692151 | 13601861001 | 203
723634 | no | yes | 32 | 25 | 25 | 19.7 | 25 | 32 mmø-25 mmø-25 mmø | 0.0000467565 | 28.7 | 42.8 | 24.9 | REHAU trójnik FASTLOC 40 - 32 - 32 | 4064299692168 | 13601871001 | 382
723642 | no | yes | 15 | 12 | 12 | 7.9 | 12 | 15 mmø-12 mmø-12 mmø | 0.00000744228 | 15.5 | 26.4 | 15.1 | REHAU trójnik FASTLOC 20 - 16 - 16 | 4064299604253 | 13601781001 | 65
723650 | no | yes | 20 | 12 | 12 | 7.9 | 12 | 20 mmø-12 mmø-12 mmø | 0.0000104199 | 16.4 | 29.1 | 15.1 | REHAU trójnik FASTLOC 25 - 16 - 16 | 4064299604246 | 13601791001 | 88
723658 | no | yes | 20 | 12 | 15 | 11.5 | 12 | 20 mmø-15 mmø-12 mmø | 0.0000108232 | 16.4 | 29.1 | 15.5 | REHAU trójnik FASTLOC 25 - 16 - 20 | 4064299604239 | 13601811001 | 96
723666 | no | yes | 20 | 15 | 12 | 7.9 | 12 | 20 mmø-12 mmø-15 mmø | 0.0000118262 | 18.3 | 29.2 | 17 | REHAU trójnik FASTLOC 25 - 20 - 16 | 4064299604222 | 13601821001 | 103

# IfcFlowFitting: Sleeve:FSL PVDF (152)
In: Level 1
Type - Material: PVDF
Type - Other - Category: Pipe Fittings; Family Name: Sleeve
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Cost: 0; Description: FSL PVDF; Manufacturer: REHAU; Model: FSL PVDF; REHAU Info: 14.02.2024-420668-420668; Type Name: FSL PVDF
Type - Materials and Finishes - Mat. Error: Error; Mat. Sleeve: PVDF
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: Sleeve:FSL PVDF; sets with these values: 2
Other - IsCustom: no; Family: Sleeve; Family and Type: Sleeve: FSL PVDF; T1: Sleeve DN; Type: FSL PVDF; Type Id: 975203
Constraints - Elevation from Level: 0 mm; Level: Level 1; Moves With Nearby Elements: no
Data - Language: Description pl; Language Tender Text: Tender Text en; PID Check: 1 mm; Region Check: Check PL; Region PID: PID PL; Region URL: Product URL DE
Dimensions - Area: 0.00262625 m2
Identity Data - ETIM Class: EC011668; ETIM Group: EG015540; ETIM Name: Accessories/spare parts for fittings; Sorting: 0; Tender text: -
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Sleeve:FSL PVDF:...) | DN1 (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
975397 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
975403 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
981779 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
981786 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
981793 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
981803 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
987656 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
987662 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
987668 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
987676 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
987682 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
987693 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
987702 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
993164 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
993170 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
993176 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
993186 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
993196 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
993206 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1011832 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1011838 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1011846 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1011854 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1011862 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1011868 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1015591 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1015597 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1019748 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1019750 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1019758 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1019760 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1019770 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1019772 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1019782 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1019784 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1019794 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1019796 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1023597 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1023599 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1023607 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1023609 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1023619 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1023621 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1023631 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1023633 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1023643 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1023645 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1031314 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1031316 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1031327 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1031329 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1031339 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1031341 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1031347 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1031349 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1035560 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1035566 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1035572 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1035580 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1035588 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1039858 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1044117 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1044121 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1044125 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1044133 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1044141 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1048368 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1052570 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1052572 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1052580 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1052582 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1052592 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1052594 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1052600 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1052602 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1052612 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1052614 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1057368 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1057370 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1057372 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1057382 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057384 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057386 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057398 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057400 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057402 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057414 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057416 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057418 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057430 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1057432 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1057434 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1057447 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057449 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057451 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057466 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057468 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057470 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057483 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057485 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1057487 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1057502 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057504 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1057506 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1057521 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057523 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1057525 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1057535 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1057537 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057539 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057551 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1057553 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057555 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057568 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057570 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057572 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057584 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1057586 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057588 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057598 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057600 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057602 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1057614 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057616 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057618 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1057631 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057633 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057635 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057651 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057653 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057655 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057671 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057673 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057675 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057690 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057692 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057694 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057709 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057711 | 32 | 35 | 0.0000235379 | REHAU tuleja zaciskowa FASTLOC 40 | 4064299608220 | 13605051001 | 626 | https://oxomi.com/p/3000126/datasheet/-/13605051001 | 0.0402
1057713 | 25 | 29.3 | 0.0000158224 | REHAU tuleja zaciskowa FASTLOC 32 | 4064299608213 | 13605041001 | 625 | https://oxomi.com/p/3000126/datasheet/-/13605041001 | 0.0265
1057723 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1057725 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057727 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1057739 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1057741 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057743 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1057756 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
1057758 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057760 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057773 | 15 | 16 | 0.00000438043 | REHAU tuleja zaciskowa FASTLOC 20 | 4064299544078 | 13605021001 | 623 | https://oxomi.com/p/3000126/datasheet/-/13605021001 | 0.0072
1057775 | 20 | 22.8 | 0.00000913289 | REHAU tuleja zaciskowa FASTLOC 25 | 4064299544061 | 13605031001 | 624 | https://oxomi.com/p/3000126/datasheet/-/13605031001 | 0.0155
1057777 | 12 | 14.2 | 0.00000277019 | REHAU tuleja zaciskowa FASTLOC 16 | 4064299544085 | 13605011001 | 622 | https://oxomi.com/p/3000126/datasheet/-/13605011001 | 0.0048
